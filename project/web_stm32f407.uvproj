# Keil uVision project web_stm32f407.uvproj, settings and files
target web (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: web_stm32f407
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx
  c include: ..\libraries\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL_Driver\Inc\Legacy;..\libraries\STM32F4xx_HAL_Driver;..\os\include;..\os\include\libc;..\bsp;..\components\finsh;..\CMSIS;..\components\drivers\include;..\components\drivers\include\drivers;..\components\drivers\include\ipc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\drv_flash;..\libraries\HAL_Drivers\config\f4;..\components\libc\compilers\armlibc;..\components\libc\compilers\armlibc\sys
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../applications/: main.c
  group Bsp
    ../bsp/: board.c stm32f4xx_hal_msp.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_common.c
  group DeviceDrivers
    ../components/drivers/serial/: serial.c
    ../components/drivers/misc/: pin.c
    ../components/drivers/src/: completion.c dataqueue.c
  group OS
    ../os/kernel/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group CMSIS
    ../CMSIS/: startup_stm32f407xx.s system_stm32f4xx.c
  group Port
    ../os/port/: context_rvds.S cpuport.c
  group Libc
    ../components/libc/compilers/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
  group Finsh
    ../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group STM32F4xx_HAL
    ../libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
